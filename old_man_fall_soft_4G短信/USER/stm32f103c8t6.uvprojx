# Keil uVision project stm32f103c8t6.uvprojx, settings and files
target old_man_fall (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: our_lib +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\LIB\STM32F10x_FWLib\CORE;..\LIB\STM32F10x_FWLib\inc;..\LIB\STM32F10x_FWLib\stm32f10x;..\appcode\stm32f103c8t6\SYSTEM\delay;..\appcode\stm32f103c8t6\SYSTEM\sys;..\appcode\stm32f103c8t6\SYSTEM\usart;..\appcode\stm32f103c8t6\DRV\LED;..\appcode\stm32f103c8t6\DRV\KEY;..\appcode\stm32f103c8t6\DRV\OLED;..\appcode\stm32f103c8t6\DRV\IIC;..\appcode\stm32f103c8t6\DRV\ADC;..\appcode\stm32f103c8t6\DRV\AUDIO;..\appcode\stm32f103c8t6\DRV\ROMFLASH;..\appcode\stm32f103c8t6\MENU;..\appcode\stm32f103c8t6\APP;..\appcode\stm32f103c8t6\DRV\MAX30102;..\appcode\stm32f103c8t6\DRV\Mpu_6050;..\appcode\stm32f103c8t6\DRV\GPS;..\appcode\stm32f103c8t6\DRV\SMS;..\appcode\stm32f103c8t6\DRV\TIMER;..\appcode\stm32f103c8t6\DRV\HC_SR04;..\appcode\stm32f103c8t6\DRV\DS18B20;..\appcode\stm32f103c8t6\cloudPlatform\Gizwits;..\appcode\stm32f103c8t6\cloudPlatform\Utils
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
    ../LIB/STM32F10x_FWLib/stm32f10x/: stm32f10x_it.c system_stm32f10x.c
  group APP
    ../appcode/stm32f103c8t6/APP/: app.c crc.c FFT_256.c config.c
  group SETUP
    ../LIB/STM32F10x_FWLib/CORE/: startup_stm32f10x_hd.s core_cm3.c
  group LIB
    ../LIB/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../LIB/LIB/: our_lib.lib
  group SYSTEM
    ../appcode/stm32f103c8t6/SYSTEM/delay/: delay.c
    ../appcode/stm32f103c8t6/SYSTEM/sys/: sys.c
    ../appcode/stm32f103c8t6/SYSTEM/usart/: usart.c
  group DRV
    ../appcode/stm32f103c8t6/DRV/LED/: led.c
    ../appcode/stm32f103c8t6/DRV/KEY/: key.c
    ../appcode/stm32f103c8t6/DRV/Mpu_6050/: Mpu_6050.c
    ../appcode/stm32f103c8t6/DRV/TIMER/: timer.c
    ../appcode/stm32f103c8t6/DRV/DS18B20/: ds18b20.c
    ../appcode/stm32f103c8t6/DRV/SMS/: sms4g.c
  group OLED
    ../appcode/stm32f103c8t6/DRV/OLED/: gui.c mymath.c
  group MENU
    ../appcode/stm32f103c8t6/MENU/: mainhmi.c menu.c menu_key.c main_set_menu_hmi.c
  group CLOUD
    ../appcode/stm32f103c8t6/cloudPlatform/Gizwits/: gizwits_product.c gizwits_protocol.c
    ../appcode/stm32f103c8t6/cloudPlatform/Utils/: common.c dataPointTools.c gagent_md5.c ringbuffer.c
